## Kconfig
```kconfig
config 88XXAU
	tristate "Realtek 88XXau USB WiFi"
	---help---
	  Support for 8812au, 8821au and 8814au
```
